# Keil uVision project TemplateProject.uvprojx, settings and files
target nrf52840 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: TemplateProject
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src;.\src\nrfx;.\lib\nrfx;.\lib\nrfx\drivers\include;.\lib\nrfx\hal;.\lib\nrfx\helpers
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group Application
    ./src/: main.c
  group Lib/nrfx
    ./lib/nrfx/drivers/src/: nrfx_gpiote.c
software components: Device:Startup 8.29.0, Device:StartupConfig 8.29.0
